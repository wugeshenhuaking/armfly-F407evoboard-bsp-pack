# Keil uVision project project.uvprojx, settings and files
target Flash (6230000::V6.23::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: .\keil-build-viewer.exe
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32F407xx,USE_FULL_LL_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\Components\CherryUSB;..\..\Components\CherryUSB\core;..\..\Components\CherryUSB\common;..\..\Components\CherryUSB\port\dwc2;..\..\Components\CherryUSB\class\cdc;..\..\Components\CherryUSB\class\hub;..\..\Components\CherryUSB\class\hid;..\..\User\user_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c utility.c utility.h
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c bsp_usb.c
    ../../User/bsp/TOUCH/: ctiic.c ctiic.h ft5206.c ft5206.h gt9xxx.c gt9xxx.h touch.c touch.h
    ../../User/bsp/LCD/: lcd.c lcd.h
    ../../User/bsp/24CXX/: 24cxx.c 24cxx.h
    ../../User/bsp/IIC/: myiic.c myiic.h
    ../../User/bsp/SRAM/: sram.c sram.h
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group HAL_Driver
    ../../User/bsp/: stm32f4xx_hal_conf.h
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group Component/cherryUSB/port
    ../../Components/CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_dwc2_param.h usb_dwc2_reg.h usb_glue_st.c
  group Component/cherryUSB/user-config
    ../../Components/CherryUSB/: usb_config.h
  group Component/cherryUSB/core
    ../../Components/CherryUSB/core/: usbd_core.c usbd_core.h usbotg_core.c usbotg_core.h
  group Component/cherryUSB/common
    ../../Components/CherryUSB/common/: usb_dc.h usb_dcache.h usb_def.h usb_errno.h usb_hc.h usb_list.h usb_log.h usb_memcpy.h usb_mempool.h usb_osal.h usb_otg.h usb_ringbuffer.h usb_util.h usb_version.h
  group Component/cherryUSB/cdc
    ../../Components/CherryUSB/class/cdc/: usb_cdc.h usbd_cdc.h usbd_cdc_acm.c usbd_cdc_acm.h usbd_cdc_ecm.c usbd_cdc_ecm.h
  group Component/cherryUSB/hid
    ../../Components/CherryUSB/class/hid/: usb_hid.h usbd_hid.c usbd_hid.h
  group Component/cherryUSB/demo
    ../../Components/CherryUSB/demo/: webusb_hid_template.c
  group Task_USB
    ../../User/user_task/: task_usb.c task_usb.h test_cdc.c test_cdc.h test_hid.c test_hid.h test_webusb.c test_webusb.h
  group SYSTEM
    ../../User/SYSTEM/sys/: sys.c
    ../../User/SYSTEM/delay/: delay.c
